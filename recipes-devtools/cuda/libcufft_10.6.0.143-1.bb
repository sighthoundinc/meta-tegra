require cuda-shared-binaries.inc

MAINSUM = "471be4b1f4d3c53eeed9e5ee7b6303b64f551475b3d6ae2fdbfbcf51481b721e"
MAINSUM:x86-64 = "da24602c922726ec146cc95eb9d35c165d436c971a12f444880a192500baadcd"
DEVSUM = "b22b3acc7a8432186934c61d0008bc66c8e2e5995b1117a250ae4598f1b70afd"
DEVSUM:x86-64 = "b13a116bf0388af97c135e3027f8e0a528e52943f4636e2a66981f731ff84a9a"

BBCLASSEXTEND = "native nativesdk"

