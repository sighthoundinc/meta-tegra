require cuda-shared-binaries.inc

MAINSUM = "34f44a172ec78beb05b2ac21207f1f5d485841f88f6a6b4de6ca71b64531bf37"
MAINSUM:x86-64 = "0613b4680ec620280a970fe9c0c6cd25faa4363950cb72eea953bfcfd175a5b4"
DEVSUM = "b9e8e720d55fe896414838b98cdec4937139b1794f501a4abc976d13a61882aa"
DEVSUM:x86-64 = "1a7e2a7f11d24e61fcbf32276eb881780d0f2d81f9b11f362a3350fef56a15ca"

BBCLASSEXTEND = "native nativesdk"
