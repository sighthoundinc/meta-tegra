require cuda-shared-binaries.inc

MAINSUM = "481625f71ad867e54124a620bb1a8c443108779552a48f703ff056bf32a79310"
MAINSUM:x86-64 = "c9ab28e6a445ec908e1c4e181dcbd226158882c816384f94d2a95ed772a58943"
DEVSUM = "0312f8b49e2f9dbeab252776d10c6dadb78567b698c0972d337b7f75771817d2"
DEVSUM:x86-64 = "b66463078d9ec867793a09332b85fdda0618ef7326e0d87d47d06574e8a9200a"

RDEPENDS:${PN} = "libcublas"
BBCLASSEXTEND = "native nativesdk"
