require cuda-shared-binaries.inc

MAINSUM = "a242dbb215962f93de693200f2df9973a1dedf05caed006b9bb3d4528c307b38"
MAINSUM:x86-64 = "aec9f4b48087ed216199fc91484c1e34f09010092d27a8096d530b060a08a1d8"
DEVSUM = "26141be23b96bc62882792093f230280d0ff1373f18ea4aa070619d4e2b72cb1"
DEVSUM:x86-64 = "aba9ea8f20ea75f389116aeb9e662d6d829d147e60a4ce8752882793b6733117"

BBCLASSEXTEND = "native nativesdk"
