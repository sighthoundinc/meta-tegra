require cuda-shared-binaries.inc

MAINSUM = "aae29f14c35e8d5ca236245c10e70642cf75cb410a774b6662e1173dc32087ad"
MAINSUM:x86-64 = "0868fab3838f1d9527316ceddbb47141d20ff061043e1b75815d87fc76ff942d"
DEVSUM = "ac08bad2703e2e3653041498919704dda831e5d8a41d47d4a10840bbb06dabb7"
DEVSUM:x86-64 = "d94d0c6dc9d33e142ad9a0f5fb8392576f948295881e65e129206979331edca9"

BBCLASSEXTEND = "native nativesdk"
